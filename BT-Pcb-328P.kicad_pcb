# Repository d-diot/BT-Pcb-328P

File README.md:

# d-diot BT-Pcb-328P

Kicad project files of the d-diot BT-Pcb-328P board.
The board is part of the [d-diot project](https://www.d-diot.com).
See the [blog post](https://www.d-diot.com/2019/11/09/bt-pcb-328p/) or the dedicated [wiki page](https://wiki.d-diot.com/hardware/pcb/mysensors/bt_pcb_328p) to know more about this board.

See the latest [release](https://github.com/d-diot/BT-Pcb-328P/releases) to download the gerber files to manufacture this board.

## Applications of this PCB:

[MySensors](https://www.mysensors.org/) battery powered and [3d printable](https://www.thingiverse.com/thing:3968135) wireless [Multisensor](https://wiki.d-diot.com/sensors_and_actuators/mysensors/d-diot_battery_powered_multisensor) for motion, light, temperature and humidity detection.
MySensors is compatible with a lot of open source home automation software like Home Assistant (which is the one included in the [d-diot hub](https://www.d-diot.com/2020/05/24/d-diot-hub-v-2-0/) and [image](https://www.d-diot.com/?s=d-diot+image)), OpenHAB, Domoticz, etc... See [here](https://www.mysensors.org/controller) for a complete list.

## Firmware

The [repository](https://github.com/d-diot/BT-Pcb-328P-firmware) of the firmware associated to this board is here.

## KiCad design BT-Pcb-328P.kicad_pcb

Parts:
BT1, BT2: AAA Cell; AAA-Keystone-5204-5226-NO-SILK
BT3: CR2032; BatteryHolder_Keystone_1058_1x2032
C1: 22uF-Tantalum; CAPPC3528X210N
C2, C9: 10uF; C_0805_2012Metric
C3, C4, C5, C6, C7, C10, C11, C12: 0.1uF; C_0805_2012Metric
C8: 100uF-Tantalum; TAJD107K016RNJV
C13: 100uF; CP_Elec_6.3x5.4
C14: 47uF; CP_Elec_5x5.4
D1: SS14
D2: R-LED; LED_0805_2012Metric
D3: B-LED; LED_0805_2012Metric
D4, D5: Y-LED; LED_0805_2012Metric
D6: G-LED; LED_0805_2012Metric
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2: FTDI; PinSocket_1x06_P2.54mm_Vertical
J3: ICSP; PinHeader_2x03_P2.54mm_Vertical
J4: ANT; PinHeader_1x01_P2.54mm_Vertical
J5: Si7021; PinHeader_1x04_P2.54mm_Vertical
J6: Vin; PinHeader_1x02_P2.54mm_Vertical
JP2: Vraw; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: Radio-rst; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels
L1: 22uH; L_6.3x6.3_H3
P1: MYSX_2.6
Q1: FDN338P; SSOT-3
Q2, Q3, Q6: FDN337N; SSOT-3
R1, R2, R4, R9: 10K; R_0805_2012Metric
R3, R5: 20K; R_0805_2012Metric
R6: R_PHOTO; R_LDR_5.0x4.1mm_P3mm_Vertical
R7: 56K; R_0805_2012Metric
R8, R11, R12, R13: 330; R_0805_2012Metric
R10: 120; R_0805_2012Metric
SW1, SW2: 1437566-3; SW_1437566-3
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: AS312; PIR-AS312-3PIN
U3: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U4: RFM69HW; RFM69HW_SMD_ThroughHole_Handsoldering
U5: ME2188C33; SOT-23-5
U6: ATSHA204A; SOT-23_Handsoldering
U7: NRF24L01
U8: NRF24L01; NRF24L01-SMD

Connections:
+3.3V: C7.2, C8.1, P1.2 (+3.3V), R10.2, U2.1 (VIN), U5.2 (VOUT)
A0: D2.1 (K), P1.15 (D9_A3), U3.23
A1: D4.1 (K), P1.16 (D10_A4), U3.24
A2: D6.1 (K), P1.21 (A5), U3.25
A3: P1.8 (LEGACY_ID), R9.2, U3.26, U6.1 (SDA)
A4-SDA: J5.3, P1.14 (D8_SDA), U3.27
A5-SCL: J5.4, P1.13 (D7_SCL), U3.28
A6: P1.22 (A6), U3.19
A7: C10.2, R6.2, R7.1, U3.22
D0-RXD: J2.4, P1.6 (D2_DTM), U3.30
D1-TXD: J2.5, P1.5 (D1_DFM), U3.31
D2: P1.9 (D3_INT), U3.32, U4.2 (DIO0), U7.8 (IRQ), U8.8 (IRQ)
D3: P1.10 (D4_INT), Q2.3 (D), R5.1, SW2.2, U3.1
D4: U3.2, U5.1 (CE)
D5: P1.11 (D5_PWM), Q3.1 (G), U3.9
D6: P1.12 (D6_PWM), R12.2, U3.10
D8: J5.2, R6.1, U3.12
D9: JP3.1 (A), U3.13, U7.3 (CE), U8.3 (CE)
DTR: C6.2, J2.6
Ext-Pwr: Q6.3 (D), R3.1, U3.11
GND: BT2.2 (-), BT3.2 (-), C1.2, C2.2, C3.2, C4.1, C5.1, C7.1, C8.2, C9.1, C10.1, C11.1, C12.1, C13.2, C14.2, D5.1 (K), J1.5 (GND), J2.1, J2.2, J3.6, J5.1, J6.1, JP3.3 (B), P1.4 (GND), Q2.2 (S), Q3.2 (S), Q6.2 (S), R1.1, R7.2, SW1.1, SW2.1, U1.1 (GND), U2.3 (GND), U3.3, U3.5, U3.21, U4.9 (GND), U4.11 (GND), U5.4 (GND), U6.3 (GND), U7.1 (GND), U8.1 (GND)
MISO: J3.1, P1.18 (D12_MISO), U3.16, U4.13 (MISO), U7.7 (MISO), U8.7 (MISO)
MOSI: J3.4, P1.17 (D11_MOSI), U3.15, U4.14 (MOSI), U7.6 (MOSI), U8.6 (MOSI)
NSS: P1.20 (D14_CS), U3.14, U4.15 (NSS), U7.4 (CSN), U8.4 (CSN)
unnamed: BT1.1 (+), BT3.1 (+), C13.1, Q1.3 (D)
unnamed: BT1.2 (-), BT2.1 (+)
unnamed: C1.1, D1.2 (A), J2.3, J3.2, Q1.1 (G), Q6.1 (G), R1.2, U1.2 (VO)
unnamed: C2.1, J1.1 (VBUS), J6.2, JP2.2 (B), U1.3 (VI)
unnamed: C3.1, U3.20
unnamed: D2.2 (A), R8.1
unnamed: D3.1 (K), Q3.3 (D)
unnamed: D3.2 (A), R10.1
unnamed: D4.2 (A), R11.1
unnamed: D5.2 (A), R12.1
unnamed: D6.2 (A), R13.1
unnamed: J4.1, U4.10 (ANA)
unnamed: JP3.2 (C), U4.1 (RESET)
unnamed: L1.2, U5.5 (LX)
unnamed: Q2.1 (G), R4.1
unnamed: R4.2, U2.2 (VOUT)
RESET: C6.1, J3.5, P1.7 (RST), R2.1, SW1.2, U3.29
SCK: J3.3, P1.19 (D13_SCK), U3.17, U4.12 (SCK), U7.5 (SCK), U8.5 (SCK)
VCC: C4.2, C5.2, C9.2, C11.2, C12.2, C14.1, D1.1 (K), L1.1, P1.3 (VCCio), Q1.2 (S), R2.2, R3.2, R5.2, R8.2, R9.1, R11.2, R13.2, U3.4, U3.6, U3.18, U4.8 (3.3V), U6.2 (VCC), U7.2 (VCC), U8.2 (VCC)
Vraw: JP2.1 (A), P1.1 (Vraw)

Board: 2 copper layers, 57.0 x 57.0 mm, 60 parts (10 on the bottom side), 44 nets.

## Commit log

2019-07-07 Development 1
2019-07-14 Development 2
2019-07-14 Development 3
2019-07-14 Development 4
2019-07-14 Development 5
2019-07-17 Development 6
2019-07-19 BP-Pcb-328P v.1.0
2019-07-20 Added Vin + and - text
2019-09-05 added HTML BOM
2019-09-14 board v.2.0
2019-10-02 board v.3.0
2019-10-02 readded nrf24l01 smd footprint
2020-07-15 added gerber files suitable for manufacturing with PCBWay
